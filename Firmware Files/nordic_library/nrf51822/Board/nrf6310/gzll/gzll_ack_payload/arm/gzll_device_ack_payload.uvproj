# Keil uVision project gzll_device_ack_payload.uvproj, settings and files
target gzll_device_ack_payload (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: gzll_device_ack_payload +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\gzll;..\..\..\..\..\Include;..\;
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --info=inline
  group app
    ../: main_device_ack_payload.c
  group system
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../Lib/gzll/arm/: gzll_arm.lib
