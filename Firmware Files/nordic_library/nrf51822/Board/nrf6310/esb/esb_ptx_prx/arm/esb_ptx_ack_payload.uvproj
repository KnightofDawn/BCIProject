# Keil uVision project esb_ptx_ack_payload.uvproj, settings and files
target esb_ptx_ack_payload (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: esb_ptx_ack_payload +hex
  c flags: Optim=4
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\esb;..\..\..\..\..\Include;..\;
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --info=inline
  group app
    ../: main_esb_ptx_ack_payload.c
  group system
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../Lib/esb/arm/: esb_arm.lib
